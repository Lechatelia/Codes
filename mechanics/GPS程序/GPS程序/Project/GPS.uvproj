# Keil uVision project GPS.uvproj, settings and files
target GPS (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GPS
  c flags: v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\User;..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\STM32F10x_StdPeriph_Driver\inc;..\owner\h;..\General_Functions\h
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c
  group StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c misc.c stm32f10x_can.c stm32f10x_tim.c stm32f10x_dma.c
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
  group Startup
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group owner
    ../owner/c/: gyro.c qei.c SysTick.c usart.c init.c gps.c lcd.c encoder.c can_database.c Command.c can.c flash.c pwm.c
  group General_Functions
    ../General_Functions/c/: mymath.c
